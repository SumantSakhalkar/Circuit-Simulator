*Q1 Project
V1	1	0	AC  1 dc 1
*V1 	1 0 PULSE(0V 1V 0s 0.1ns 0.1ns 5ns 10ns)
R1  1   2   50
R2  3   0   120
R3  0   4   50
R4  5   0   120
V2	6	0	AC  1 dc 1
*V2 	6 0 PULSE(0V 1V 0s 0.1ns 0.1ns 5ns 10ns)
R5  6   7   50
R6  8   0   120

CTL11 2 0 5.872857e-14

RTL11 2 9 1.033571e-02

LTL11 9 10 4.257643e-10

ETL11 10 11 64 65 2.400249e-04

ETL12 11 12 123 124 1.654661e-04

CTL12 12 0 5.872857e-14

RTL12 12 13 1.033571e-02

LTL12 13 14 4.257643e-10

ETL13 14 15 68 69 2.400249e-04

ETL14 15 16 127 128 1.654661e-04

CTL13 16 0 5.872857e-14

RTL13 16 17 1.033571e-02

LTL13 17 18 4.257643e-10

ETL15 18 19 72 73 2.400249e-04

ETL16 19 20 131 132 1.654661e-04

CTL14 20 0 5.872857e-14

RTL14 20 21 1.033571e-02

LTL14 21 22 4.257643e-10

ETL17 22 23 76 77 2.400249e-04

ETL18 23 24 135 136 1.654661e-04

CTL15 24 0 5.872857e-14

RTL15 24 25 1.033571e-02

LTL15 25 26 4.257643e-10

ETL19 26 27 80 81 2.400249e-04

ETL110 27 28 139 140 1.654661e-04

CTL16 28 0 5.872857e-14

RTL16 28 29 1.033571e-02

LTL16 29 30 4.257643e-10

ETL111 30 31 84 85 2.400249e-04

ETL112 31 32 143 144 1.654661e-04

CTL17 32 0 5.872857e-14

RTL17 32 33 1.033571e-02

LTL17 33 34 4.257643e-10

ETL113 34 35 88 89 2.400249e-04

ETL114 35 36 147 148 1.654661e-04

CTL18 36 0 5.872857e-14

RTL18 36 37 1.033571e-02

LTL18 37 38 4.257643e-10

ETL115 38 39 92 93 2.400249e-04

ETL116 39 40 151 152 1.654661e-04

CTL19 40 0 5.872857e-14

RTL19 40 41 1.033571e-02

LTL19 41 42 4.257643e-10

ETL117 42 43 96 97 2.400249e-04

ETL118 43 44 155 156 1.654661e-04

CTL110 44 0 5.872857e-14

RTL110 44 45 1.033571e-02

LTL110 45 46 4.257643e-10

ETL119 46 47 100 101 2.400249e-04

ETL120 47 48 159 160 1.654661e-04

CTL111 48 0 5.872857e-14

RTL111 48 49 1.033571e-02

LTL111 49 50 4.257643e-10

ETL121 50 51 104 105 2.400249e-04

ETL122 51 52 163 164 1.654661e-04

CTL112 52 0 5.872857e-14

RTL112 52 53 1.033571e-02

LTL112 53 54 4.257643e-10

ETL123 54 55 108 109 2.400249e-04

ETL124 55 56 167 168 1.654661e-04

CTL113 56 0 5.872857e-14

RTL113 56 57 1.033571e-02

LTL113 57 58 4.257643e-10

ETL125 58 59 112 113 2.400249e-04

ETL126 59 60 171 172 1.654661e-04

CTL114 60 0 5.872857e-14

RTL114 60 61 1.033571e-02

LTL114 61 62 4.257643e-10

ETL127 62 63 116 117 2.400249e-04

ETL128 63 3 175 176 1.654661e-04

CTL21 4 0 6.390667e-14

RTL21 4 64 9.646667e-03

LTL21 64 65 3.734533e-10

ETL21 65 66 9 10 2.105346e-04

ETL22 66 67 123 124 2.166097e-04

CTL22 67 0 6.390667e-14

RTL22 67 68 9.646667e-03

LTL22 68 69 3.734533e-10

ETL23 69 70 13 14 2.105346e-04

ETL24 70 71 127 128 2.166097e-04

CTL23 71 0 6.390667e-14

RTL23 71 72 9.646667e-03

LTL23 72 73 3.734533e-10

ETL25 73 74 17 18 2.105346e-04

ETL26 74 75 131 132 2.166097e-04

CTL24 75 0 6.390667e-14

RTL24 75 76 9.646667e-03

LTL24 76 77 3.734533e-10

ETL27 77 78 21 22 2.105346e-04

ETL28 78 79 135 136 2.166097e-04

CTL25 79 0 6.390667e-14

RTL25 79 80 9.646667e-03

LTL25 80 81 3.734533e-10

ETL29 81 82 25 26 2.105346e-04

ETL210 82 83 139 140 2.166097e-04

CTL26 83 0 6.390667e-14

RTL26 83 84 9.646667e-03

LTL26 84 85 3.734533e-10

ETL211 85 86 29 30 2.105346e-04

ETL212 86 87 143 144 2.166097e-04

CTL27 87 0 6.390667e-14

RTL27 87 88 9.646667e-03

LTL27 88 89 3.734533e-10

ETL213 89 90 33 34 2.105346e-04

ETL214 90 91 147 148 2.166097e-04

CTL28 91 0 6.390667e-14

RTL28 91 92 9.646667e-03

LTL28 92 93 3.734533e-10

ETL215 93 94 37 38 2.105346e-04

ETL216 94 95 151 152 2.166097e-04

CTL29 95 0 6.390667e-14

RTL29 95 96 9.646667e-03

LTL29 96 97 3.734533e-10

ETL217 97 98 41 42 2.105346e-04

ETL218 98 99 155 156 2.166097e-04

CTL210 99 0 6.390667e-14

RTL210 99 100 9.646667e-03

LTL210 100 101 3.734533e-10

ETL219 101 102 45 46 2.105346e-04

ETL220 102 103 159 160 2.166097e-04

CTL211 103 0 6.390667e-14

RTL211 103 104 9.646667e-03

LTL211 104 105 3.734533e-10

ETL221 105 106 49 50 2.105346e-04

ETL222 106 107 163 164 2.166097e-04

CTL212 107 0 6.390667e-14

RTL212 107 108 9.646667e-03

LTL212 108 109 3.734533e-10

ETL223 109 110 53 54 2.105346e-04

ETL224 110 111 167 168 2.166097e-04

CTL213 111 0 6.390667e-14

RTL213 111 112 9.646667e-03

LTL213 112 113 3.734533e-10

ETL225 113 114 57 58 2.105346e-04

ETL226 114 115 171 172 2.166097e-04

CTL214 115 0 6.390667e-14

RTL214 115 116 9.646667e-03

LTL214 116 117 3.734533e-10

ETL227 117 118 61 62 2.105346e-04

ETL228 118 119 175 176 2.166097e-04

CTL215 119 0 6.390667e-14

RTL215 119 120 9.646667e-03

LTL215 120 121 3.734533e-10

ETL229 121 122 9 10 2.105346e-04

ETL230 122 5 123 124 2.166097e-04

CTL31 7 0 6.237143e-14

RTL31 7 123 1.033571e-02

LTL31 123 124 3.993357e-10

ETL31 124 125 13 14 1.551951e-04

ETL32 125 126 120 121 2.316220e-04

CTL32 126 0 6.237143e-14

RTL32 126 127 1.033571e-02

LTL32 127 128 3.993357e-10

ETL33 128 129 17 18 1.551951e-04

ETL34 129 130 64 65 2.316220e-04

CTL33 130 0 6.237143e-14

RTL33 130 131 1.033571e-02

LTL33 131 132 3.993357e-10

ETL35 132 133 21 22 1.551951e-04

ETL36 133 134 68 69 2.316220e-04

CTL34 134 0 6.237143e-14

RTL34 134 135 1.033571e-02

LTL34 135 136 3.993357e-10

ETL37 136 137 25 26 1.551951e-04

ETL38 137 138 72 73 2.316220e-04

CTL35 138 0 6.237143e-14

RTL35 138 139 1.033571e-02

LTL35 139 140 3.993357e-10

ETL39 140 141 29 30 1.551951e-04

ETL310 141 142 76 77 2.316220e-04

CTL36 142 0 6.237143e-14

RTL36 142 143 1.033571e-02

LTL36 143 144 3.993357e-10

ETL311 144 145 33 34 1.551951e-04

ETL312 145 146 80 81 2.316220e-04

CTL37 146 0 6.237143e-14

RTL37 146 147 1.033571e-02

LTL37 147 148 3.993357e-10

ETL313 148 149 37 38 1.551951e-04

ETL314 149 150 84 85 2.316220e-04

CTL38 150 0 6.237143e-14

RTL38 150 151 1.033571e-02

LTL38 151 152 3.993357e-10

ETL315 152 153 41 42 1.551951e-04

ETL316 153 154 88 89 2.316220e-04

CTL39 154 0 6.237143e-14

RTL39 154 155 1.033571e-02

LTL39 155 156 3.993357e-10

ETL317 156 157 45 46 1.551951e-04

ETL318 157 158 92 93 2.316220e-04

CTL310 158 0 6.237143e-14

RTL310 158 159 1.033571e-02

LTL310 159 160 3.993357e-10

ETL319 160 161 49 50 1.551951e-04

ETL320 161 162 96 97 2.316220e-04

CTL311 162 0 6.237143e-14

RTL311 162 163 1.033571e-02

LTL311 163 164 3.993357e-10

ETL321 164 165 53 54 1.551951e-04

ETL322 165 166 100 101 2.316220e-04

CTL312 166 0 6.237143e-14

RTL312 166 167 1.033571e-02

LTL312 167 168 3.993357e-10

ETL323 168 169 57 58 1.551951e-04

ETL324 169 170 104 105 2.316220e-04

CTL313 170 0 6.237143e-14

RTL313 170 171 1.033571e-02

LTL313 171 172 3.993357e-10

ETL325 172 173 61 62 1.551951e-04

ETL326 173 174 108 109 2.316220e-04

CTL314 174 0 6.237143e-14

RTL314 174 175 1.033571e-02

LTL314 175 176 3.993357e-10

ETL327 176 177 9 10 1.551951e-04

ETL328 177 8 112 113 2.316220e-04

CCTL1TL21 2 4 -1.809286e-14

CCTL1TL31 2 7 -8.771429e-15

CCTL2TL31 4 7 -1.809286e-14

CCTL1TL22 12 67 -1.809286e-14

CCTL1TL23 16 71 -1.809286e-14

CCTL1TL24 20 75 -1.809286e-14

CCTL1TL25 24 79 -1.809286e-14

CCTL1TL26 28 83 -1.809286e-14

CCTL1TL27 32 87 -1.809286e-14

CCTL1TL28 36 91 -1.809286e-14

CCTL1TL29 40 95 -1.809286e-14

CCTL1TL210 44 99 -1.809286e-14

CCTL1TL211 48 103 -1.809286e-14

CCTL1TL212 52 107 -1.809286e-14

CCTL1TL213 56 111 -1.809286e-14

CCTL1TL214 60 115 -1.809286e-14

CCTL1TL32 12 126 -8.771429e-15

CCTL1TL33 16 130 -8.771429e-15

CCTL1TL34 20 134 -8.771429e-15

CCTL1TL35 24 138 -8.771429e-15

CCTL1TL36 28 142 -8.771429e-15

CCTL1TL37 32 146 -8.771429e-15

CCTL1TL38 36 150 -8.771429e-15

CCTL1TL39 40 154 -8.771429e-15

CCTL1TL310 44 158 -8.771429e-15

CCTL1TL311 48 162 -8.771429e-15

CCTL1TL312 52 166 -8.771429e-15

CCTL1TL313 56 170 -8.771429e-15

CCTL1TL314 60 174 -8.771429e-15

CCTL2TL32 67 126 -1.809286e-14

CCTL2TL33 71 130 -1.809286e-14

CCTL2TL34 75 134 -1.809286e-14

CCTL2TL35 79 138 -1.809286e-14

CCTL2TL36 83 142 -1.809286e-14

CCTL2TL37 87 146 -1.809286e-14

CCTL2TL38 91 150 -1.809286e-14

CCTL2TL39 95 154 -1.809286e-14

CCTL2TL310 99 158 -1.809286e-14

CCTL2TL311 103 162 -1.809286e-14

CCTL2TL312 107 166 -1.809286e-14

CCTL2TL313 111 170 -1.809286e-14

CCTL2TL314 115 174 -1.809286e-14

CCTL2TL315 119 178 -1.809286e-14

.ac LIN 600 100000  10000000000

*.tran 0.01ns 10ns

.option post=1

.end
