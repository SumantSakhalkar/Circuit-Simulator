*Q1 Project
*V1	1	0	AC  1 dc 1
V1 	1 0 PULSE(0V 1V 0s 0.1ns 0.1ns 5ns 10ns)
R1  1   2   50
R2  3   0   120
R3  0   4   50
R4  5   0   120
*V2	6	0	AC  1 dc 1
V2 	6 0 PULSE(0V 1V 0s 0.1ns 0.1ns 5ns 10ns)
R5  6   7   50
R6  8   0   120

CTL11 2 0 5.872857e-14

RTL11 2 9 1.033571e-02

LTL11 9 10 4.257643e-10

ETL11 10 11 148 149 2.400249e-04

ETL12 11 12 295 296 1.654661e-04

CTL12 12 0 5.872857e-14

RTL12 12 13 1.033571e-02

LTL12 13 14 4.257643e-10

ETL13 14 15 152 153 2.400249e-04

ETL14 15 16 299 300 1.654661e-04

CTL13 16 0 5.872857e-14

RTL13 16 17 1.033571e-02

LTL13 17 18 4.257643e-10

ETL15 18 19 156 157 2.400249e-04

ETL16 19 20 303 304 1.654661e-04

CTL14 20 0 5.872857e-14

RTL14 20 21 1.033571e-02

LTL14 21 22 4.257643e-10

ETL17 22 23 160 161 2.400249e-04

ETL18 23 24 307 308 1.654661e-04

CTL15 24 0 5.872857e-14

RTL15 24 25 1.033571e-02

LTL15 25 26 4.257643e-10

ETL19 26 27 164 165 2.400249e-04

ETL110 27 28 311 312 1.654661e-04

CTL16 28 0 5.872857e-14

RTL16 28 29 1.033571e-02

LTL16 29 30 4.257643e-10

ETL111 30 31 168 169 2.400249e-04

ETL112 31 32 315 316 1.654661e-04

CTL17 32 0 5.872857e-14

RTL17 32 33 1.033571e-02

LTL17 33 34 4.257643e-10

ETL113 34 35 172 173 2.400249e-04

ETL114 35 36 319 320 1.654661e-04

CTL18 36 0 5.872857e-14

RTL18 36 37 1.033571e-02

LTL18 37 38 4.257643e-10

ETL115 38 39 176 177 2.400249e-04

ETL116 39 40 323 324 1.654661e-04

CTL19 40 0 5.872857e-14

RTL19 40 41 1.033571e-02

LTL19 41 42 4.257643e-10

ETL117 42 43 180 181 2.400249e-04

ETL118 43 44 327 328 1.654661e-04

CTL110 44 0 5.872857e-14

RTL110 44 45 1.033571e-02

LTL110 45 46 4.257643e-10

ETL119 46 47 184 185 2.400249e-04

ETL120 47 48 331 332 1.654661e-04

CTL111 48 0 5.872857e-14

RTL111 48 49 1.033571e-02

LTL111 49 50 4.257643e-10

ETL121 50 51 188 189 2.400249e-04

ETL122 51 52 335 336 1.654661e-04

CTL112 52 0 5.872857e-14

RTL112 52 53 1.033571e-02

LTL112 53 54 4.257643e-10

ETL123 54 55 192 193 2.400249e-04

ETL124 55 56 339 340 1.654661e-04

CTL113 56 0 5.872857e-14

RTL113 56 57 1.033571e-02

LTL113 57 58 4.257643e-10

ETL125 58 59 196 197 2.400249e-04

ETL126 59 60 343 344 1.654661e-04

CTL114 60 0 5.872857e-14

RTL114 60 61 1.033571e-02

LTL114 61 62 4.257643e-10

ETL127 62 63 200 201 2.400249e-04

ETL128 63 64 347 348 1.654661e-04

CTL115 64 0 5.872857e-14

RTL115 64 65 1.033571e-02

LTL115 65 66 4.257643e-10

ETL129 66 67 204 205 2.400249e-04

ETL130 67 68 351 352 1.654661e-04

CTL116 68 0 5.872857e-14

RTL116 68 69 1.033571e-02

LTL116 69 70 4.257643e-10

ETL131 70 71 208 209 2.400249e-04

ETL132 71 72 355 356 1.654661e-04

CTL117 72 0 5.872857e-14

RTL117 72 73 1.033571e-02

LTL117 73 74 4.257643e-10

ETL133 74 75 212 213 2.400249e-04

ETL134 75 76 359 360 1.654661e-04

CTL118 76 0 5.872857e-14

RTL118 76 77 1.033571e-02

LTL118 77 78 4.257643e-10

ETL135 78 79 216 217 2.400249e-04

ETL136 79 80 363 364 1.654661e-04

CTL119 80 0 5.872857e-14

RTL119 80 81 1.033571e-02

LTL119 81 82 4.257643e-10

ETL137 82 83 220 221 2.400249e-04

ETL138 83 84 367 368 1.654661e-04

CTL120 84 0 5.872857e-14

RTL120 84 85 1.033571e-02

LTL120 85 86 4.257643e-10

ETL139 86 87 224 225 2.400249e-04

ETL140 87 88 371 372 1.654661e-04

CTL121 88 0 5.872857e-14

RTL121 88 89 1.033571e-02

LTL121 89 90 4.257643e-10

ETL141 90 91 228 229 2.400249e-04

ETL142 91 92 375 376 1.654661e-04

CTL122 92 0 5.872857e-14

RTL122 92 93 1.033571e-02

LTL122 93 94 4.257643e-10

ETL143 94 95 232 233 2.400249e-04

ETL144 95 96 379 380 1.654661e-04

CTL123 96 0 5.872857e-14

RTL123 96 97 1.033571e-02

LTL123 97 98 4.257643e-10

ETL145 98 99 236 237 2.400249e-04

ETL146 99 100 383 384 1.654661e-04

CTL124 100 0 5.872857e-14

RTL124 100 101 1.033571e-02

LTL124 101 102 4.257643e-10

ETL147 102 103 240 241 2.400249e-04

ETL148 103 104 387 388 1.654661e-04

CTL125 104 0 5.872857e-14

RTL125 104 105 1.033571e-02

LTL125 105 106 4.257643e-10

ETL149 106 107 244 245 2.400249e-04

ETL150 107 108 391 392 1.654661e-04

CTL126 108 0 5.872857e-14

RTL126 108 109 1.033571e-02

LTL126 109 110 4.257643e-10

ETL151 110 111 248 249 2.400249e-04

ETL152 111 112 395 396 1.654661e-04

CTL127 112 0 5.872857e-14

RTL127 112 113 1.033571e-02

LTL127 113 114 4.257643e-10

ETL153 114 115 252 253 2.400249e-04

ETL154 115 116 399 400 1.654661e-04

CTL128 116 0 5.872857e-14

RTL128 116 117 1.033571e-02

LTL128 117 118 4.257643e-10

ETL155 118 119 256 257 2.400249e-04

ETL156 119 120 403 404 1.654661e-04

CTL129 120 0 5.872857e-14

RTL129 120 121 1.033571e-02

LTL129 121 122 4.257643e-10

ETL157 122 123 260 261 2.400249e-04

ETL158 123 124 407 408 1.654661e-04

CTL130 124 0 5.872857e-14

RTL130 124 125 1.033571e-02

LTL130 125 126 4.257643e-10

ETL159 126 127 264 265 2.400249e-04

ETL160 127 128 411 412 1.654661e-04

CTL131 128 0 5.872857e-14

RTL131 128 129 1.033571e-02

LTL131 129 130 4.257643e-10

ETL161 130 131 268 269 2.400249e-04

ETL162 131 132 415 416 1.654661e-04

CTL132 132 0 5.872857e-14

RTL132 132 133 1.033571e-02

LTL132 133 134 4.257643e-10

ETL163 134 135 272 273 2.400249e-04

ETL164 135 136 419 420 1.654661e-04

CTL133 136 0 5.872857e-14

RTL133 136 137 1.033571e-02

LTL133 137 138 4.257643e-10

ETL165 138 139 276 277 2.400249e-04

ETL166 139 140 423 424 1.654661e-04

CTL134 140 0 5.872857e-14

RTL134 140 141 1.033571e-02

LTL134 141 142 4.257643e-10

ETL167 142 143 280 281 2.400249e-04

ETL168 143 144 427 428 1.654661e-04

CTL135 144 0 5.872857e-14

RTL135 144 145 1.033571e-02

LTL135 145 146 4.257643e-10

ETL169 146 147 284 285 2.400249e-04

ETL170 147 3 431 432 1.654661e-04

CTL21 4 0 6.477027e-14

RTL21 4 148 9.777027e-03

LTL21 148 149 3.785000e-10

ETL21 149 150 9 10 2.133796e-04

ETL22 150 151 295 296 2.195369e-04

CTL22 151 0 6.477027e-14

RTL22 151 152 9.777027e-03

LTL22 152 153 3.785000e-10

ETL23 153 154 13 14 2.133796e-04

ETL24 154 155 299 300 2.195369e-04

CTL23 155 0 6.477027e-14

RTL23 155 156 9.777027e-03

LTL23 156 157 3.785000e-10

ETL25 157 158 17 18 2.133796e-04

ETL26 158 159 303 304 2.195369e-04

CTL24 159 0 6.477027e-14

RTL24 159 160 9.777027e-03

LTL24 160 161 3.785000e-10

ETL27 161 162 21 22 2.133796e-04

ETL28 162 163 307 308 2.195369e-04

CTL25 163 0 6.477027e-14

RTL25 163 164 9.777027e-03

LTL25 164 165 3.785000e-10

ETL29 165 166 25 26 2.133796e-04

ETL210 166 167 311 312 2.195369e-04

CTL26 167 0 6.477027e-14

RTL26 167 168 9.777027e-03

LTL26 168 169 3.785000e-10

ETL211 169 170 29 30 2.133796e-04

ETL212 170 171 315 316 2.195369e-04

CTL27 171 0 6.477027e-14

RTL27 171 172 9.777027e-03

LTL27 172 173 3.785000e-10

ETL213 173 174 33 34 2.133796e-04

ETL214 174 175 319 320 2.195369e-04

CTL28 175 0 6.477027e-14

RTL28 175 176 9.777027e-03

LTL28 176 177 3.785000e-10

ETL215 177 178 37 38 2.133796e-04

ETL216 178 179 323 324 2.195369e-04

CTL29 179 0 6.477027e-14

RTL29 179 180 9.777027e-03

LTL29 180 181 3.785000e-10

ETL217 181 182 41 42 2.133796e-04

ETL218 182 183 327 328 2.195369e-04

CTL210 183 0 6.477027e-14

RTL210 183 184 9.777027e-03

LTL210 184 185 3.785000e-10

ETL219 185 186 45 46 2.133796e-04

ETL220 186 187 331 332 2.195369e-04

CTL211 187 0 6.477027e-14

RTL211 187 188 9.777027e-03

LTL211 188 189 3.785000e-10

ETL221 189 190 49 50 2.133796e-04

ETL222 190 191 335 336 2.195369e-04

CTL212 191 0 6.477027e-14

RTL212 191 192 9.777027e-03

LTL212 192 193 3.785000e-10

ETL223 193 194 53 54 2.133796e-04

ETL224 194 195 339 340 2.195369e-04

CTL213 195 0 6.477027e-14

RTL213 195 196 9.777027e-03

LTL213 196 197 3.785000e-10

ETL225 197 198 57 58 2.133796e-04

ETL226 198 199 343 344 2.195369e-04

CTL214 199 0 6.477027e-14

RTL214 199 200 9.777027e-03

LTL214 200 201 3.785000e-10

ETL227 201 202 61 62 2.133796e-04

ETL228 202 203 347 348 2.195369e-04

CTL215 203 0 6.477027e-14

RTL215 203 204 9.777027e-03

LTL215 204 205 3.785000e-10

ETL229 205 206 65 66 2.133796e-04

ETL230 206 207 351 352 2.195369e-04

CTL216 207 0 6.477027e-14

RTL216 207 208 9.777027e-03

LTL216 208 209 3.785000e-10

ETL231 209 210 69 70 2.133796e-04

ETL232 210 211 355 356 2.195369e-04

CTL217 211 0 6.477027e-14

RTL217 211 212 9.777027e-03

LTL217 212 213 3.785000e-10

ETL233 213 214 73 74 2.133796e-04

ETL234 214 215 359 360 2.195369e-04

CTL218 215 0 6.477027e-14

RTL218 215 216 9.777027e-03

LTL218 216 217 3.785000e-10

ETL235 217 218 77 78 2.133796e-04

ETL236 218 219 363 364 2.195369e-04

CTL219 219 0 6.477027e-14

RTL219 219 220 9.777027e-03

LTL219 220 221 3.785000e-10

ETL237 221 222 81 82 2.133796e-04

ETL238 222 223 367 368 2.195369e-04

CTL220 223 0 6.477027e-14

RTL220 223 224 9.777027e-03

LTL220 224 225 3.785000e-10

ETL239 225 226 85 86 2.133796e-04

ETL240 226 227 371 372 2.195369e-04

CTL221 227 0 6.477027e-14

RTL221 227 228 9.777027e-03

LTL221 228 229 3.785000e-10

ETL241 229 230 89 90 2.133796e-04

ETL242 230 231 375 376 2.195369e-04

CTL222 231 0 6.477027e-14

RTL222 231 232 9.777027e-03

LTL222 232 233 3.785000e-10

ETL243 233 234 93 94 2.133796e-04

ETL244 234 235 379 380 2.195369e-04

CTL223 235 0 6.477027e-14

RTL223 235 236 9.777027e-03

LTL223 236 237 3.785000e-10

ETL245 237 238 97 98 2.133796e-04

ETL246 238 239 383 384 2.195369e-04

CTL224 239 0 6.477027e-14

RTL224 239 240 9.777027e-03

LTL224 240 241 3.785000e-10

ETL247 241 242 101 102 2.133796e-04

ETL248 242 243 387 388 2.195369e-04

CTL225 243 0 6.477027e-14

RTL225 243 244 9.777027e-03

LTL225 244 245 3.785000e-10

ETL249 245 246 105 106 2.133796e-04

ETL250 246 247 391 392 2.195369e-04

CTL226 247 0 6.477027e-14

RTL226 247 248 9.777027e-03

LTL226 248 249 3.785000e-10

ETL251 249 250 109 110 2.133796e-04

ETL252 250 251 395 396 2.195369e-04

CTL227 251 0 6.477027e-14

RTL227 251 252 9.777027e-03

LTL227 252 253 3.785000e-10

ETL253 253 254 113 114 2.133796e-04

ETL254 254 255 399 400 2.195369e-04

CTL228 255 0 6.477027e-14

RTL228 255 256 9.777027e-03

LTL228 256 257 3.785000e-10

ETL255 257 258 117 118 2.133796e-04

ETL256 258 259 403 404 2.195369e-04

CTL229 259 0 6.477027e-14

RTL229 259 260 9.777027e-03

LTL229 260 261 3.785000e-10

ETL257 261 262 121 122 2.133796e-04

ETL258 262 263 407 408 2.195369e-04

CTL230 263 0 6.477027e-14

RTL230 263 264 9.777027e-03

LTL230 264 265 3.785000e-10

ETL259 265 266 125 126 2.133796e-04

ETL260 266 267 411 412 2.195369e-04

CTL231 267 0 6.477027e-14

RTL231 267 268 9.777027e-03

LTL231 268 269 3.785000e-10

ETL261 269 270 129 130 2.133796e-04

ETL262 270 271 415 416 2.195369e-04

CTL232 271 0 6.477027e-14

RTL232 271 272 9.777027e-03

LTL232 272 273 3.785000e-10

ETL263 273 274 133 134 2.133796e-04

ETL264 274 275 419 420 2.195369e-04

CTL233 275 0 6.477027e-14

RTL233 275 276 9.777027e-03

LTL233 276 277 3.785000e-10

ETL265 277 278 137 138 2.133796e-04

ETL266 278 279 423 424 2.195369e-04

CTL234 279 0 6.477027e-14

RTL234 279 280 9.777027e-03

LTL234 280 281 3.785000e-10

ETL267 281 282 141 142 2.133796e-04

ETL268 282 283 427 428 2.195369e-04

CTL235 283 0 6.477027e-14

RTL235 283 284 9.777027e-03

LTL235 284 285 3.785000e-10

ETL269 285 286 145 146 2.133796e-04

ETL270 286 287 431 432 2.195369e-04

CTL236 287 0 6.477027e-14

RTL236 287 288 9.777027e-03

LTL236 288 289 3.785000e-10

ETL271 289 290 9 10 2.133796e-04

ETL272 290 291 295 296 2.195369e-04

CTL237 291 0 6.477027e-14

RTL237 291 292 9.777027e-03

LTL237 292 293 3.785000e-10

ETL273 293 294 13 14 2.133796e-04

ETL274 294 5 299 300 2.195369e-04

CTL31 7 0 6.237143e-14

RTL31 7 295 1.033571e-02

LTL31 295 296 3.993357e-10

ETL31 296 297 17 18 1.551951e-04

ETL32 297 298 288 289 2.316220e-04

CTL32 298 0 6.237143e-14

RTL32 298 299 1.033571e-02

LTL32 299 300 3.993357e-10

ETL33 300 301 21 22 1.551951e-04

ETL34 301 302 292 293 2.316220e-04

CTL33 302 0 6.237143e-14

RTL33 302 303 1.033571e-02

LTL33 303 304 3.993357e-10

ETL35 304 305 25 26 1.551951e-04

ETL36 305 306 148 149 2.316220e-04

CTL34 306 0 6.237143e-14

RTL34 306 307 1.033571e-02

LTL34 307 308 3.993357e-10

ETL37 308 309 29 30 1.551951e-04

ETL38 309 310 152 153 2.316220e-04

CTL35 310 0 6.237143e-14

RTL35 310 311 1.033571e-02

LTL35 311 312 3.993357e-10

ETL39 312 313 33 34 1.551951e-04

ETL310 313 314 156 157 2.316220e-04

CTL36 314 0 6.237143e-14

RTL36 314 315 1.033571e-02

LTL36 315 316 3.993357e-10

ETL311 316 317 37 38 1.551951e-04

ETL312 317 318 160 161 2.316220e-04

CTL37 318 0 6.237143e-14

RTL37 318 319 1.033571e-02

LTL37 319 320 3.993357e-10

ETL313 320 321 41 42 1.551951e-04

ETL314 321 322 164 165 2.316220e-04

CTL38 322 0 6.237143e-14

RTL38 322 323 1.033571e-02

LTL38 323 324 3.993357e-10

ETL315 324 325 45 46 1.551951e-04

ETL316 325 326 168 169 2.316220e-04

CTL39 326 0 6.237143e-14

RTL39 326 327 1.033571e-02

LTL39 327 328 3.993357e-10

ETL317 328 329 49 50 1.551951e-04

ETL318 329 330 172 173 2.316220e-04

CTL310 330 0 6.237143e-14

RTL310 330 331 1.033571e-02

LTL310 331 332 3.993357e-10

ETL319 332 333 53 54 1.551951e-04

ETL320 333 334 176 177 2.316220e-04

CTL311 334 0 6.237143e-14

RTL311 334 335 1.033571e-02

LTL311 335 336 3.993357e-10

ETL321 336 337 57 58 1.551951e-04

ETL322 337 338 180 181 2.316220e-04

CTL312 338 0 6.237143e-14

RTL312 338 339 1.033571e-02

LTL312 339 340 3.993357e-10

ETL323 340 341 61 62 1.551951e-04

ETL324 341 342 184 185 2.316220e-04

CTL313 342 0 6.237143e-14

RTL313 342 343 1.033571e-02

LTL313 343 344 3.993357e-10

ETL325 344 345 65 66 1.551951e-04

ETL326 345 346 188 189 2.316220e-04

CTL314 346 0 6.237143e-14

RTL314 346 347 1.033571e-02

LTL314 347 348 3.993357e-10

ETL327 348 349 69 70 1.551951e-04

ETL328 349 350 192 193 2.316220e-04

CTL315 350 0 6.237143e-14

RTL315 350 351 1.033571e-02

LTL315 351 352 3.993357e-10

ETL329 352 353 73 74 1.551951e-04

ETL330 353 354 196 197 2.316220e-04

CTL316 354 0 6.237143e-14

RTL316 354 355 1.033571e-02

LTL316 355 356 3.993357e-10

ETL331 356 357 77 78 1.551951e-04

ETL332 357 358 200 201 2.316220e-04

CTL317 358 0 6.237143e-14

RTL317 358 359 1.033571e-02

LTL317 359 360 3.993357e-10

ETL333 360 361 81 82 1.551951e-04

ETL334 361 362 204 205 2.316220e-04

CTL318 362 0 6.237143e-14

RTL318 362 363 1.033571e-02

LTL318 363 364 3.993357e-10

ETL335 364 365 85 86 1.551951e-04

ETL336 365 366 208 209 2.316220e-04

CTL319 366 0 6.237143e-14

RTL319 366 367 1.033571e-02

LTL319 367 368 3.993357e-10

ETL337 368 369 89 90 1.551951e-04

ETL338 369 370 212 213 2.316220e-04

CTL320 370 0 6.237143e-14

RTL320 370 371 1.033571e-02

LTL320 371 372 3.993357e-10

ETL339 372 373 93 94 1.551951e-04

ETL340 373 374 216 217 2.316220e-04

CTL321 374 0 6.237143e-14

RTL321 374 375 1.033571e-02

LTL321 375 376 3.993357e-10

ETL341 376 377 97 98 1.551951e-04

ETL342 377 378 220 221 2.316220e-04

CTL322 378 0 6.237143e-14

RTL322 378 379 1.033571e-02

LTL322 379 380 3.993357e-10

ETL343 380 381 101 102 1.551951e-04

ETL344 381 382 224 225 2.316220e-04

CTL323 382 0 6.237143e-14

RTL323 382 383 1.033571e-02

LTL323 383 384 3.993357e-10

ETL345 384 385 105 106 1.551951e-04

ETL346 385 386 228 229 2.316220e-04

CTL324 386 0 6.237143e-14

RTL324 386 387 1.033571e-02

LTL324 387 388 3.993357e-10

ETL347 388 389 109 110 1.551951e-04

ETL348 389 390 232 233 2.316220e-04

CTL325 390 0 6.237143e-14

RTL325 390 391 1.033571e-02

LTL325 391 392 3.993357e-10

ETL349 392 393 113 114 1.551951e-04

ETL350 393 394 236 237 2.316220e-04

CTL326 394 0 6.237143e-14

RTL326 394 395 1.033571e-02

LTL326 395 396 3.993357e-10

ETL351 396 397 117 118 1.551951e-04

ETL352 397 398 240 241 2.316220e-04

CTL327 398 0 6.237143e-14

RTL327 398 399 1.033571e-02

LTL327 399 400 3.993357e-10

ETL353 400 401 121 122 1.551951e-04

ETL354 401 402 244 245 2.316220e-04

CTL328 402 0 6.237143e-14

RTL328 402 403 1.033571e-02

LTL328 403 404 3.993357e-10

ETL355 404 405 125 126 1.551951e-04

ETL356 405 406 248 249 2.316220e-04

CTL329 406 0 6.237143e-14

RTL329 406 407 1.033571e-02

LTL329 407 408 3.993357e-10

ETL357 408 409 129 130 1.551951e-04

ETL358 409 410 252 253 2.316220e-04

CTL330 410 0 6.237143e-14

RTL330 410 411 1.033571e-02

LTL330 411 412 3.993357e-10

ETL359 412 413 133 134 1.551951e-04

ETL360 413 414 256 257 2.316220e-04

CTL331 414 0 6.237143e-14

RTL331 414 415 1.033571e-02

LTL331 415 416 3.993357e-10

ETL361 416 417 137 138 1.551951e-04

ETL362 417 418 260 261 2.316220e-04

CTL332 418 0 6.237143e-14

RTL332 418 419 1.033571e-02

LTL332 419 420 3.993357e-10

ETL363 420 421 141 142 1.551951e-04

ETL364 421 422 264 265 2.316220e-04

CTL333 422 0 6.237143e-14

RTL333 422 423 1.033571e-02

LTL333 423 424 3.993357e-10

ETL365 424 425 145 146 1.551951e-04

ETL366 425 426 268 269 2.316220e-04

CTL334 426 0 6.237143e-14

RTL334 426 427 1.033571e-02

LTL334 427 428 3.993357e-10

ETL367 428 429 9 10 1.551951e-04

ETL368 429 430 272 273 2.316220e-04

CTL335 430 0 6.237143e-14

RTL335 430 431 1.033571e-02

LTL335 431 432 3.993357e-10

ETL369 432 433 13 14 1.551951e-04

ETL370 433 8 276 277 2.316220e-04

CCTL1TL21 2 4 -1.809286e-14

CCTL1TL31 2 7 -8.771429e-15

CCTL2TL31 4 7 -1.809286e-14

CCTL1TL22 12 151 -1.809286e-14

CCTL1TL23 16 155 -1.809286e-14

CCTL1TL24 20 159 -1.809286e-14

CCTL1TL25 24 163 -1.809286e-14

CCTL1TL26 28 167 -1.809286e-14

CCTL1TL27 32 171 -1.809286e-14

CCTL1TL28 36 175 -1.809286e-14

CCTL1TL29 40 179 -1.809286e-14

CCTL1TL210 44 183 -1.809286e-14

CCTL1TL211 48 187 -1.809286e-14

CCTL1TL212 52 191 -1.809286e-14

CCTL1TL213 56 195 -1.809286e-14

CCTL1TL214 60 199 -1.809286e-14

CCTL1TL215 64 203 -1.809286e-14

CCTL1TL216 68 207 -1.809286e-14

CCTL1TL217 72 211 -1.809286e-14

CCTL1TL218 76 215 -1.809286e-14

CCTL1TL219 80 219 -1.809286e-14

CCTL1TL220 84 223 -1.809286e-14

CCTL1TL221 88 227 -1.809286e-14

CCTL1TL222 92 231 -1.809286e-14

CCTL1TL223 96 235 -1.809286e-14

CCTL1TL224 100 239 -1.809286e-14

CCTL1TL225 104 243 -1.809286e-14

CCTL1TL226 108 247 -1.809286e-14

CCTL1TL227 112 251 -1.809286e-14

CCTL1TL228 116 255 -1.809286e-14

CCTL1TL229 120 259 -1.809286e-14

CCTL1TL230 124 263 -1.809286e-14

CCTL1TL231 128 267 -1.809286e-14

CCTL1TL232 132 271 -1.809286e-14

CCTL1TL233 136 275 -1.809286e-14

CCTL1TL234 140 279 -1.809286e-14

CCTL1TL235 144 283 -1.809286e-14

CCTL1TL32 12 298 -8.771429e-15

CCTL1TL33 16 302 -8.771429e-15

CCTL1TL34 20 306 -8.771429e-15

CCTL1TL35 24 310 -8.771429e-15

CCTL1TL36 28 314 -8.771429e-15

CCTL1TL37 32 318 -8.771429e-15

CCTL1TL38 36 322 -8.771429e-15

CCTL1TL39 40 326 -8.771429e-15

CCTL1TL310 44 330 -8.771429e-15

CCTL1TL311 48 334 -8.771429e-15

CCTL1TL312 52 338 -8.771429e-15

CCTL1TL313 56 342 -8.771429e-15

CCTL1TL314 60 346 -8.771429e-15

CCTL1TL315 64 350 -8.771429e-15

CCTL1TL316 68 354 -8.771429e-15

CCTL1TL317 72 358 -8.771429e-15

CCTL1TL318 76 362 -8.771429e-15

CCTL1TL319 80 366 -8.771429e-15

CCTL1TL320 84 370 -8.771429e-15

CCTL1TL321 88 374 -8.771429e-15

CCTL1TL322 92 378 -8.771429e-15

CCTL1TL323 96 382 -8.771429e-15

CCTL1TL324 100 386 -8.771429e-15

CCTL1TL325 104 390 -8.771429e-15

CCTL1TL326 108 394 -8.771429e-15

CCTL1TL327 112 398 -8.771429e-15

CCTL1TL328 116 402 -8.771429e-15

CCTL1TL329 120 406 -8.771429e-15

CCTL1TL330 124 410 -8.771429e-15

CCTL1TL331 128 414 -8.771429e-15

CCTL1TL332 132 418 -8.771429e-15

CCTL1TL333 136 422 -8.771429e-15

CCTL1TL334 140 426 -8.771429e-15

CCTL1TL335 144 430 -8.771429e-15

CCTL2TL32 151 298 -1.809286e-14

CCTL2TL33 155 302 -1.809286e-14

CCTL2TL34 159 306 -1.809286e-14

CCTL2TL35 163 310 -1.809286e-14

CCTL2TL36 167 314 -1.809286e-14

CCTL2TL37 171 318 -1.809286e-14

CCTL2TL38 175 322 -1.809286e-14

CCTL2TL39 179 326 -1.809286e-14

CCTL2TL310 183 330 -1.809286e-14

CCTL2TL311 187 334 -1.809286e-14

CCTL2TL312 191 338 -1.809286e-14

CCTL2TL313 195 342 -1.809286e-14

CCTL2TL314 199 346 -1.809286e-14

CCTL2TL315 203 350 -1.809286e-14

CCTL2TL316 207 354 -1.809286e-14

CCTL2TL317 211 358 -1.809286e-14

CCTL2TL318 215 362 -1.809286e-14

CCTL2TL319 219 366 -1.809286e-14

CCTL2TL320 223 370 -1.809286e-14

CCTL2TL321 227 374 -1.809286e-14

CCTL2TL322 231 378 -1.809286e-14

CCTL2TL323 235 382 -1.809286e-14

CCTL2TL324 239 386 -1.809286e-14

CCTL2TL325 243 390 -1.809286e-14

CCTL2TL326 247 394 -1.809286e-14

CCTL2TL327 251 398 -1.809286e-14

CCTL2TL328 255 402 -1.809286e-14

CCTL2TL329 259 406 -1.809286e-14

CCTL2TL330 263 410 -1.809286e-14

CCTL2TL331 267 414 -1.809286e-14

CCTL2TL332 271 418 -1.809286e-14

CCTL2TL333 275 422 -1.809286e-14

CCTL2TL334 279 426 -1.809286e-14

CCTL2TL335 283 430 -1.809286e-14

CCTL2TL336 287 434 -1.809286e-14

CCTL2TL337 291 438 -1.809286e-14

*.ac LIN 600 100000  10000000000

.tran 0.01ns 10ns

.option post=1

.end
