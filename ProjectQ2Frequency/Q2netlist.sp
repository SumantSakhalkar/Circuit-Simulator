*Q1 Project
*V1	1	0	AC  1 dc 1
V1 	1 0 PULSE(0V 1V 0s 0.1ns 0.1ns 5ns 10ns)
R1  1   2   50
R2  3   0   120
R3  0   4   50
R4  5   0   120
*V2	6	0	AC  1 dc 1
V2 	6 0 PULSE(0V 1V 0s 0.1ns 0.1ns 5ns 10ns)
R5  6   7   50
R6  8   0   120

CTL11 2 0 5.872857e-14

RTL11 2 9 1.033571e-02

LTL11 9 10 4.257643e-10

ETL11 10 11 36 37 2.400249e-04

ETL12 11 12 63 64 1.654661e-04

CTL12 12 0 5.872857e-14

RTL12 12 13 1.033571e-02

LTL12 13 14 4.257643e-10

ETL13 14 15 40 41 2.400249e-04

ETL14 15 16 67 68 1.654661e-04

CTL13 16 0 5.872857e-14

RTL13 16 17 1.033571e-02

LTL13 17 18 4.257643e-10

ETL15 18 19 44 45 2.400249e-04

ETL16 19 20 71 72 1.654661e-04

CTL14 20 0 5.872857e-14

RTL14 20 21 1.033571e-02

LTL14 21 22 4.257643e-10

ETL17 22 23 48 49 2.400249e-04

ETL18 23 24 75 76 1.654661e-04

CTL15 24 0 5.872857e-14

RTL15 24 25 1.033571e-02

LTL15 25 26 4.257643e-10

ETL19 26 27 52 53 2.400249e-04

ETL110 27 28 79 80 1.654661e-04

CTL16 28 0 5.872857e-14

RTL16 28 29 1.033571e-02

LTL16 29 30 4.257643e-10

ETL111 30 31 56 57 2.400249e-04

ETL112 31 32 83 84 1.654661e-04

CTL17 32 0 5.872857e-14

RTL17 32 33 1.033571e-02

LTL17 33 34 4.257643e-10

ETL113 34 35 60 61 2.400249e-04

ETL114 35 3 87 88 1.654661e-04

CTL21 4 0 6.847143e-14

RTL21 4 36 1.033571e-02

LTL21 36 37 4.001286e-10

ETL21 37 38 9 10 2.255727e-04

ETL22 38 39 63 64 2.320819e-04

CTL22 39 0 6.847143e-14

RTL22 39 40 1.033571e-02

LTL22 40 41 4.001286e-10

ETL23 41 42 13 14 2.255727e-04

ETL24 42 43 67 68 2.320819e-04

CTL23 43 0 6.847143e-14

RTL23 43 44 1.033571e-02

LTL23 44 45 4.001286e-10

ETL25 45 46 17 18 2.255727e-04

ETL26 46 47 71 72 2.320819e-04

CTL24 47 0 6.847143e-14

RTL24 47 48 1.033571e-02

LTL24 48 49 4.001286e-10

ETL27 49 50 21 22 2.255727e-04

ETL28 50 51 75 76 2.320819e-04

CTL25 51 0 6.847143e-14

RTL25 51 52 1.033571e-02

LTL25 52 53 4.001286e-10

ETL29 53 54 25 26 2.255727e-04

ETL210 54 55 79 80 2.320819e-04

CTL26 55 0 6.847143e-14

RTL26 55 56 1.033571e-02

LTL26 56 57 4.001286e-10

ETL211 57 58 29 30 2.255727e-04

ETL212 58 59 83 84 2.320819e-04

CTL27 59 0 6.847143e-14

RTL27 59 60 1.033571e-02

LTL27 60 61 4.001286e-10

ETL213 61 62 33 34 2.255727e-04

ETL214 62 5 87 88 2.320819e-04

CTL31 7 0 6.237143e-14

RTL31 7 63 1.033571e-02

LTL31 63 64 3.993357e-10

ETL31 64 65 9 10 1.551951e-04

ETL32 65 66 36 37 2.316220e-04

CTL32 66 0 6.237143e-14

RTL32 66 67 1.033571e-02

LTL32 67 68 3.993357e-10

ETL33 68 69 13 14 1.551951e-04

ETL34 69 70 40 41 2.316220e-04

CTL33 70 0 6.237143e-14

RTL33 70 71 1.033571e-02

LTL33 71 72 3.993357e-10

ETL35 72 73 17 18 1.551951e-04

ETL36 73 74 44 45 2.316220e-04

CTL34 74 0 6.237143e-14

RTL34 74 75 1.033571e-02

LTL34 75 76 3.993357e-10

ETL37 76 77 21 22 1.551951e-04

ETL38 77 78 48 49 2.316220e-04

CTL35 78 0 6.237143e-14

RTL35 78 79 1.033571e-02

LTL35 79 80 3.993357e-10

ETL39 80 81 25 26 1.551951e-04

ETL310 81 82 52 53 2.316220e-04

CTL36 82 0 6.237143e-14

RTL36 82 83 1.033571e-02

LTL36 83 84 3.993357e-10

ETL311 84 85 29 30 1.551951e-04

ETL312 85 86 56 57 2.316220e-04

CTL37 86 0 6.237143e-14

RTL37 86 87 1.033571e-02

LTL37 87 88 3.993357e-10

ETL313 88 89 33 34 1.551951e-04

ETL314 89 8 60 61 2.316220e-04

CCTL1TL21 2 4 -1.809286e-14

CCTL1TL31 2 7 -8.771429e-15

CCTL2TL31 4 7 -1.809286e-14

CCTL1TL22 12 39 -1.809286e-14

CCTL1TL23 16 43 -1.809286e-14

CCTL1TL24 20 47 -1.809286e-14

CCTL1TL25 24 51 -1.809286e-14

CCTL1TL26 28 55 -1.809286e-14

CCTL1TL27 32 59 -1.809286e-14

CCTL1TL32 12 66 -8.771429e-15

CCTL1TL33 16 70 -8.771429e-15

CCTL1TL34 20 74 -8.771429e-15

CCTL1TL35 24 78 -8.771429e-15

CCTL1TL36 28 82 -8.771429e-15

CCTL1TL37 32 86 -8.771429e-15

CCTL2TL32 39 66 -1.809286e-14

CCTL2TL33 43 70 -1.809286e-14

CCTL2TL34 47 74 -1.809286e-14

CCTL2TL35 51 78 -1.809286e-14

CCTL2TL36 55 82 -1.809286e-14

CCTL2TL37 59 86 -1.809286e-14

.ac LIN 600 100000  10000000000

*.tran 0.01ns 10ns

.option post=1

.end
